#include "delay.h"



/********************************************************

函数功能： 延时c  ms
参    数：  c
返回  值： 无
*********************************************************/
void Delay1ms(uint c)		//@12.000MHz
{
		unsigned char i, j;
		for(;c>0;c--)
	{
				i = 2;
			j = 239;
			do
			{
				while (--j);
			} while (--i);
	}
}

/********************************************************

函数功能： 延时2*  us
参    数：  us
返回  值： 无
*********************************************************/
void Delay2us(uint us)		//@12.000MHz
{
	while(us--);
}

/********************************************************

函数功能： 延时1*  us
参    数：  us
返回  值： 无
*********************************************************/

void Delay1us(uint us)		//@12.000MHz
{
		for(;us>0;us--)
			{
				_nop_();

			}
}
